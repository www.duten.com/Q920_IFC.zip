Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-07-05T13:36:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 05 13:36:28 2021 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{66882466-94EA-4B67-94EF-7DB1D3FC55A0}\ifc * Database version: 5507 * Database creation date: Mon Jul 05 13:36:26 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 05 13:36:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 05 13:36:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: Pair of Door Handles with Brushed Stainless Steel Finish, DBLTD_Duten_DoorLeverHandleSets_Q920:Pair of Door Handles with Brushed Stainless Steel Finish:315344
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1020410 Door Hardware (Uniformat); Material: Duten_Metal_BrushedStainlessSteel
Pset_ManufacturerTypeInformation - ModelReference: Pair of Door Handles with Brushed Stainless Steel Finish; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Pair of Door Handles with Matte Black Finish, DBLTD_Duten_DoorLeverHandleSets_Q920:Pair of Door Handles with Matte Black Finish:316437
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1020410 Door Hardware (Uniformat); Material: Duten_Metal_MatteBlack
Pset_ManufacturerTypeInformation - ModelReference: Pair of Door Handles with Matte Black Finish; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Pair of Door Handles with Matte Brass Finish, DBLTD_Duten_DoorLeverHandleSets_Q920:Pair of Door Handles with Matte Brass Finish:316448
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1020410 Door Hardware (Uniformat); Material: Duten_Metal_MatteBrass
Pset_ManufacturerTypeInformation - ModelReference: Pair of Door Handles with Matte Brass Finish; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Pair of Door Handles with Matte Copper Finish, DBLTD_Duten_DoorLeverHandleSets_Q920:Pair of Door Handles with Matte Copper Finish:316450
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1020410 Door Hardware (Uniformat); Material: Duten_Metal_MatteCopper
Pset_ManufacturerTypeInformation - ModelReference: Pair of Door Handles with Matte Copper Finish; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a

# IfcFlowController: Pair of Door Handles with Polished Stainless Steel Finish, DBLTD_Duten_DoorLeverHandleSets_Q920:Pair of Door Handles with Polished Stainless Steel Finish:316471
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1020410 Door Hardware (Uniformat); Material: Duten_Metal_PolishedStainlessSteel
Pset_ManufacturerTypeInformation - ModelReference: Pair of Door Handles with Polished Stainless Steel Finish; Manufacturer: Duten
Pset_DistributionFlowElementCommon - Reference: n/a
